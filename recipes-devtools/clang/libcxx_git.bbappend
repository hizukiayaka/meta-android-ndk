DEPENDS:remove:class-target = "clang-cross-${TARGET_ARCH}"
